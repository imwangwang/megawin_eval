# Keil uVision project MG32F02A032_IAP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MG32F02A032 Megawin
  pack: Megawin.CM0_DFP.1.0.14
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MG32F02A032_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./Source/: main.c Sample_MEM_FlashAccess.c
software components: CMSIS:CORE 5.2.0, MG32x02z_Device:Startup 1.0.1, MG32x02z_Driver:Driver-All 1.0.0
